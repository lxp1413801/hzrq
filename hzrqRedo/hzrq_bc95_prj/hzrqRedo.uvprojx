# Keil uVision project hzrqRedo.uvprojx, settings and files
target 18A (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 18A-freeRTos_stm32l0xx_lpw_demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L073xx,__STDC_LIMIT_MACROS
  c misc: --CPP
  c include: .\src;.\src\bsp\stm32l0xx;..\os-cmsis;..\os-kernel\include;.\src\configs;.\src\bsp\os-port;..\sx127x;.\src\bsp\sx127xio-map;..\common-api;..\common;.\src\bsp\device\CMSIS\Include;.\src\bsp\stm32l0xx\Inc;..\qc-protocol;.\src\includes;..\hzrq-protocol
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./src/app/: main.cpp data.cpp m_event.cpp cmd_line.c nb_routines.c
  group api
    ./src/api/: ui.c valve_api.c volt-dec.c flow-ex.c m-nb-module.c
  group os/cmsis
    ../os-cmsis/: cmsis_os.c
  group os/kernel
    ../os-kernel/kernel/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group bsp/os-portable
    ./src/bsp/os-port/: port.c Port.s
    ./src/bsp/os-port/MemMang/: heap_4.c
  group bsp/startup
    ./src/bsp/startup/: startup_stm32l073xx.s
  group bsp/system
    ./src/bsp/system/: stm32l0xx_it.c system_stm32l0xx.c
  group bsp/dirver
    ./src/bsp/stm32l0xx/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group bsp/interface
    ./src/bsp/interface/: m_clock_config.c m_flash.c m_gpio_config.c m_pwr_mng.c m_rtc.c m_uart.c m_rng.c m_lcd.c m_lcd_hal.c m_buzzer.c m_adc.c m_iic.c
  group depend
    ../common/: crc16_sf.c time-stamp.c m_string.c sha256.c m_aes_sf.c
  group qc-protocol
    ../qc-protocol/: 15e-data-protocol.c data-protocol-ex.c
    ../hzrq-protocol/: hzrq-data-record.c hzrq-comm-protocol.c
software components: CMSIS:CORE 5.0.1
